# Keil uVision project Breakout.uvprojx, settings and files
target Target 1 (::::)
  device: STM32F303K8Tx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000,0x00003000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Breakout
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Source Group 1
    ./: main.c breakout.h breakout.c USART.h USART.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.11.3
